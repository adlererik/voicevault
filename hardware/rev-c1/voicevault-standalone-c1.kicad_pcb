# Repository adlererik/voicevault (continued)

## KiCad design hardware/rev-c1/voicevault-standalone-c1.kicad_pcb (continued)

Board: 6 copper layers, 216 parts (0 on the bottom side), 132 nets, no tracks yet.

Other parts of the board:
H1, H2, H3, H4: M2 mounting hole / not an assembled component; MountingHole_2.2mm_M2

File hardware/rev-c1/BOM-REVIEW.csv (part):

reference,value,footprint,status
AE201,2450AT18B0100001E,VoiceVault_B0:Johanson_2450AT18x100,REVIEW — not purchasing/fabrication approval
C10,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C107,2.2u 10V,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C108,10u 10V,VoiceVault_B0:C_0805_2012Metric,REVIEW — not purchasing/fabrication approval
C109,4.7u 10V,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C11,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C110,1u 10V,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C1101,100n 10V,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C1102,100n 10V,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C1103,1u 10V,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C111,1u 10V,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C112,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C113,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C114,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C115,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C12,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C1201,10u 25V X7S,VoiceVault_B0:C_0805_2012Metric,REVIEW — not purchasing/fabrication approval
C1202,10u 25V X7S,VoiceVault_B0:C_0805_2012Metric,REVIEW — not purchasing/fabrication approval
C1203,22u 16V X6S,VoiceVault_B0:C_0805_2012Metric,REVIEW — not purchasing/fabrication approval
C1204,22u 16V X6S,VoiceVault_B0:C_0805_2012Metric,REVIEW — not purchasing/fabrication approval
C1205,22u 16V X6S,VoiceVault_B0:C_0805_2012Metric,REVIEW — not purchasing/fabrication approval
C1206,100n 25V,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C1207,100n 10V,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C1208,10n,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C13,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C14,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C15,4.7u 10V,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C16,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C17,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C18,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C19,4.7u 10V,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C20,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C201,16p C0G 2%,VoiceVault_B0:C_0201_0603Metric,REVIEW — not purchasing/fabrication approval
C202,16p C0G 2%,VoiceVault_B0:C_0201_0603Metric,REVIEW — not purchasing/fabrication approval
C203,0.8p C0G 5%,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C204,100n X7R 10%,VoiceVault_B0:C_0201_0603Metric,REVIEW — not purchasing/fabrication approval
C205,100n X7R 10%,VoiceVault_B0:C_0201_0603Metric,REVIEW — not purchasing/fabrication approval
C207,100p C0G 5%,VoiceVault_B0:C_0201_0603Metric,REVIEW — not purchasing/fabrication approval
C208,4.7u X5R 10V,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C209,1u X5R 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C21,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C210,12p C0G 2%,VoiceVault_B0:C_0201_0603Metric,REVIEW — not purchasing/fabrication approval
C211,12p C0G 2%,VoiceVault_B0:C_0201_0603Metric,REVIEW — not purchasing/fabrication approval
C212,1.2p C0G; VNA tune,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C213,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C214,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C215,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C216,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C22,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C23,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C24,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C25,10u 10V,VoiceVault_B0:C_0805_2012Metric,REVIEW — not purchasing/fabrication approval
C26,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C27,2.2u 10V,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C301,12p C0G 5%,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C302,12p C0G 5%,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C303,12p C0G 5%,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C304,12p C0G 5%,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C305,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C306,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C401,2.2u 10V,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C402,10u 10V,VoiceVault_B0:C_0805_2012Metric,REVIEW — not purchasing/fabrication approval
C403,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C404,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C405,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C501,100n 16V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C502,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C503,4.7u 16V,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C504,10u 10V,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C505,10u 10V,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C6,4.7u 10V,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C601,10u 10V,VoiceVault_B0:C_0805_2012Metric,REVIEW — not purchasing/fabrication approval
C602,10u 10V,VoiceVault_B0:C_0805_2012Metric,REVIEW — not purchasing/fabrication approval
C603,10u 10V,VoiceVault_B0:C_0805_2012Metric,REVIEW — not purchasing/fabrication approval
C604,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C605,10u 10V,VoiceVault_B0:C_0805_2012Metric,REVIEW — not purchasing/fabrication approval
C606,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C607,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C608,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C609,1u 10V X7R,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C610,33p C0G,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
C611,220u 6.3V polymer; exact MPN qualification pending,VoiceVault_B0:CP_EIA-7343-31_Kemet-D,REVIEW — not purchasing/fabrication approval
C612,220u 6.3V polymer; exact MPN qualification pending,VoiceVault_B0:CP_EIA-7343-31_Kemet-D,REVIEW — not purchasing/fabrication approval
C614,2.2u 10V,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C615,2.2u 10V,VoiceVault_B0:C_0603_1608Metric,REVIEW — not purchasing/fabrication approval
C7,100n 10V,VoiceVault_B0:C_0402_1005Metric,REVIEW — not purchasing/fabrication approval
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